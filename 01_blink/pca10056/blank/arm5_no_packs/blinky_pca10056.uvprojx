# Keil uVision project blinky_pca10056.uvprojx, settings and files
target nrf52840_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET NRF52840_XXAA
  c misc: --reduce_paths
  c include: D:\nRF5_SDK_14.0.0\components;D:\nRF5_SDK_14.0.0\components\boards;D:\nRF5_SDK_14.0.0\components\drivers_nrf\delay;D:\nRF5_SDK_14.0.0\components\drivers_nrf\hal;D:\nRF5_SDK_14.0.0\components\drivers_nrf\nrf_soc_nosd;D:\nRF5_SDK_14.0.0\components\libraries\balloc;D:\nRF5_SDK_14.0.0\components\libraries\bsp;D:\nRF5_SDK_14.0.0\components\libraries\experimental_log;D:\nRF5_SDK_14.0.0\components\libraries\experimental_log\src;D:\nRF5_SDK_14.0.0\components\libraries\experimental_memobj;D:\nRF5_SDK_14.0.0\components\libraries\experimental_section_vars;D:\nRF5_SDK_14.0.0\components\libraries\strerror;D:\nRF5_SDK_14.0.0\components\libraries\util;D:\nRF5_SDK_14.0.0\components\toolchain;..\..\..;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DNRF52840_XXAA
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x22000 size 0xde000
  memory RVCT9: RAM 0x20002128 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    D:/nRF5_SDK_14.0.0/components/boards/: boards.c
  group nRF_Libraries
    D:/nRF5_SDK_14.0.0/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c
    D:/nRF5_SDK_14.0.0/components/libraries/strerror/: nrf_strerror.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.14.1
